## sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_AUTOSTART_ARDUINO=y
CONFIG_LWIP_PPP_SUPPORT=y
CONFIG_PPP_SUPPORT=y
```
